# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VE ST STM32L475VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L431xx; RT_USING_DLIBC; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: libraries\HAL_Drivers\config; rt-thread\include; libraries\HAL_Drivers; libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc; rt-thread\libcpu\arm\common; rt-thread\libcpu\arm\cortex-m4; libraries\STM32L4xx_HAL\CMSIS\Include; rt-thread\components\finsh; .; packages\FlexibleButton-v1.0.0; applications; libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include; rt-thread\components\libc\compilers\dlib; rt-thread\components\drivers\include; board; board\CubeMX_Config\Inc; modules\event; rt-thread\components\libc\compilers\common; modules\lora
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: crc.c gpio_scaner.c lora_drv.c main.c pm_test.c wdt_idle.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l431xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_pm.c drv_pmtim.c drv_wdt.c drv_common.c
    libraries/HAL_Drivers/drv_pmhw/: drv_pmhw_l4.c
  group iotb_event
    modules/event/: iotb_event.c
  group iotb_lora
    modules/lora/: iotb_lora_process.c
  group flex_button
    packages/FlexibleButton-v1.0.0/: flexible_button.c flexible_button_demo.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/pm/: pm.c
    rt-thread/components/drivers/rtc/: rtc.c soft_rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group STM32_HAL
    libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_lptim.c
